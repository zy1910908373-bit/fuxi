# Keil uVision project project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SUPPORT_RTOS
  c include: ..\User;..\BSP\LEDs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group BSP
    ../BSP/LEDs/: bsp_led.c
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, CMSIS:RTOS2:FreeRTOS 10.5.1, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, Device:Libopt 3.3.0, Device:Startup 3.3.0, Device:StdPeripherals:GPIO 3.3.0, Device:StdPeripherals:MISC 3.3.0, Device:StdPeripherals:PMU 3.3.0, Device:StdPeripherals:RCU 3.3.0, Device:StdPeripherals:USART 3.3.0
