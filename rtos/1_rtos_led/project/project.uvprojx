# Keil uVision project project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F407,USE_STDPERIPH_DRIVER,SUPPORT_RTOS
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Utilities;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\Hardware\LEDs;..\Hardware\Buzzer;..\Task;..\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_timer.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group FreeRTOS
    ../User/: FreeRTOSConfig.h
  group FreeRTOS/core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group BSP/LEDS
    ../Hardware/LEDs/: bsp_led.c
  group BSP/BUZZER
    ../Hardware/Buzzer/: buzzer.c
  group Task
    ../Task/: self_task.c
  group APP
    ../APP/: app_key.c App.h
